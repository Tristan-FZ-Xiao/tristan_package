## proc_demo/src/Kconfig
```kconfig
config PROC_DEMO
    tristate "Demo for proc fs"
    help
        Demo for how to use proc fs
```
